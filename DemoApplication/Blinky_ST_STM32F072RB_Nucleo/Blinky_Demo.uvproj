# Keil uVision project Blinky_Demo.uvproj, settings and files
target Blinky Demo (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Blinky_Demo +hex
  c flags: Optim=3 oTime=1
  c define: __GENERIC_ARM_ARMV6__,SCOPE_SIZE=3000
  c include: .\STMicroelectronics\inc;..\..\Controller\Common;..\..\Controller\Services;..\..\Controller\Driver\Serial;..\..\Controller\Protocol\LNet;..\..\Library\General\Controller\inc;.\inc;.\X2CCode;.\
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group STMicroelectronics
    ./STMicroelectronics/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
    ./STMicroelectronics/startup/: startup_stm32f0xx.s
  group Core
    ../../Controller/Common/: CommonFcts.c TableStruct.c
    ../../Controller/Protocol/LNet/: LNet.c
    ../../Controller/Driver/Serial/: SerialGeneric.c
    ../../Controller/Services/: Services.c BlockServicesX2C.c
    ../../Library/General/Controller/src/: Scope_Main.c
  group Blocks
    ../../Library/General/Controller/lib/: STM32F0_General.lib
  group Model
    ./X2CCode/: X2C.c
  group Application
    ./src/: Hardware.c Main.c
